# SPDX-License-Identifier: MIT
# No desktop UI, cellular stack, cloud setup, VPN or connectivity probes.
PACKAGECONFIG = "systemd wifi nmcli readline polkit gnutls"
