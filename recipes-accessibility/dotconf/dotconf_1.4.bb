# SPDX-License-Identifier: MIT
SUMMARY = "Configuration-file parser for Speech Dispatcher"
HOMEPAGE = "https://github.com/williamh/dotconf"
LICENSE = "LGPL-2.1-or-later"
LIC_FILES_CHKSUM = "file://COPYING;md5=155b66f2dc258f05886f9886a60fd870"
SRC_URI = "git://github.com/williamh/dotconf.git;protocol=https;branch=master"
SRCREV = "ed5c5a1707ed55b45904f875f6b25ce9076f4fa6"
inherit autotools pkgconfig
