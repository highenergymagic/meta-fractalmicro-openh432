# SPDX-License-Identifier: MIT
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-nl80211-no-probe-ies-for-passive-scan.patch"
